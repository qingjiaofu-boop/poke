# Keil uVision project STC_BSP_Gomoku.uvproj, settings and files
target STC-B Gomoku (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC_BSP_Gomoku +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: main.c STCBSP_V3.6.LIB
